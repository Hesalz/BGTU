#pragma warning(disable : 4996)

#include <iostream>
#include <windows.h>
#include <string>
#include <sstream>

#include "../OS13_HTCOM_LIB/pch.h"
#include "../OS13_HTCOM_LIB/OS13_HTCOM_LIB.h"

#ifdef _WIN64
#pragma comment(lib, "../x64/Debug/OS13_HTCOM_LIB.lib")
#else
#pragma comment(lib, "../Debug/OS13_HTCOM_LIB.lib")
#endif

using namespace std;

string intToString(int number);
int charToInt(char* str);
string incrementPayload(char* str);
wchar_t* getWC(const char* c);

int main(int argc, char* argv[])
{
    HANDLE hStopEvent = OpenEvent(SYNCHRONIZE, FALSE, L"Stop");
    HANDLE hResumeEvent = OpenEvent(SYNCHRONIZE, FALSE, L"Resume");

    setlocale(LC_ALL, "Russian");

    try
    {
        cout << "Инициализация компонента:" << endl;
        OS13_HTCOM_HANDEL h = OS13_HTCOM::Init();

        wchar_t* fileName = getWC(argv[1]);
        ht::HtHandle* ht = OS13_HTCOM::HT::open(h, fileName, true);

        if (!ht)
            throw "-- open: error";
        else
            cout << "-- open: success" << endl;

        cout << "[UPDATE] Рабочий цикл запущен" << endl;

        while (true)
        {
          
            if (WaitForSingleObject(hStopEvent, 0) == WAIT_OBJECT_0)
            {
                cout << "[UPDATE] Пауза. Ждем Resume..." << endl;
                WaitForSingleObject(hResumeEvent, INFINITE);
                cout << "[UPDATE] Возобновление работы!" << endl;
            }

            int numberKey = rand() % 50;
            string key = intToString(numberKey);
            cout << "[UPDATE] Обновляем ключ: " << key << endl;

            ht::Element* getElem =
                OS13_HTCOM::Element::createGetElement(h, key.c_str(), key.length() + 1);

            ht::Element* element = OS13_HTCOM::HT::get(h, ht, getElem);

            delete getElem;

            if (element)
            {
                cout << "-- get: success" << endl;

                string newPayload = incrementPayload((char*)element->payload);

                if (OS13_HTCOM::HT::update(
                    h,
                    ht,
                    element,
                    newPayload.c_str(),
                    newPayload.length() + 1))
                {
                    cout << "-- update: success" << endl;
                }
                else
                {
                    cout << "-- update: error" << endl;
                }

                OS13_HTCOM::Dispose(h);
            }
            else
            {
                cout << "-- get: error (элемента нет)" << endl;
            }

            Sleep(1000);
        }

        OS13_HTCOM::HT::close(h, ht);
        OS13_HTCOM::Dispose(h);
    }
    catch (const char* e) { cout << e << endl; }
    catch (int e) { cout << "HRESULT: " << e << endl; }
}

string intToString(int number)
{
    stringstream convert;
    convert << number;
    return convert.str();
}

int charToInt(char* str)
{
    stringstream convert;
    convert << str;
    int num;
    convert >> num;
    return num;
}

string incrementPayload(char* str)
{
    int oldNumber = charToInt(str);
    int newNumber = oldNumber + 1;
    return intToString(newNumber);
}

wchar_t* getWC(const char* c)
{
    wchar_t* wc = new wchar_t[strlen(c) + 1];
    mbstowcs(wc, c, strlen(c) + 1);
    return wc;
}
