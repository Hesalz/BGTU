#pragma warning(disable : 4996)

#include <iostream>
#include <windows.h>
#include <sstream>
#include <conio.h>


#include "../OS13_HTCOM_LIB/pch.h"
#include "../OS13_HTCOM_LIB/OS13_HTCOM_LIB.h"

#ifdef _WIN64
#pragma comment(lib, "../x64/Debug/OS13_HTCOM_LIB.lib")
#else
#pragma comment(lib, "../Debug/OS13_HTCOM_LIB.lib")
#endif

using namespace std;

string intToString(int number);
wchar_t* getWC(const char* c);

int main(int argc, char* argv[])
{
	HANDLE hStopEvent = OpenEvent(SYNCHRONIZE, FALSE, L"Stop");
	HANDLE hResumeEvent = OpenEvent(SYNCHRONIZE, FALSE, L"Resume");


	setlocale(LC_ALL, "Russian");

	try
	{

		wchar_t* fileName = getWC(argv[1]);
		cout << "Инициализация компонента:" << endl;
		OS13_HTCOM_HANDEL h = OS13_HTCOM::Init();

        ht::HtHandle* ht = OS13_HTCOM::HT::open(h, fileName, true);
        if (!ht)
            throw "-- open: error";

        cout << "[0402] Рабочий цикл запущен" << endl;

        while (true)
        {
            if (WaitForSingleObject(hStopEvent, 0) == WAIT_OBJECT_0)
            {
                cout << "[0402] Пауза. Ждем Resume..." << endl;
                WaitForSingleObject(hResumeEvent, INFINITE);
                cout << "[0402] Возобновление работы!" << endl;
            }

            int number = rand() % 50;
            string key = intToString(number);
            cout << key << endl;

            ht::Element* element =
                OS13_HTCOM::Element::createInsertElement(h, key.c_str(), key.length() + 1, "0", 2);

            if (OS13_HTCOM::HT::insert(h, ht, element))
                cout << "-- insert: success" << endl;
            else
                cout << "-- insert: error" << endl;

            delete element;

            Sleep(1000);
        }

        OS13_HTCOM::HT::close(h, ht);
        OS13_HTCOM::Dispose(h);
    }
    catch (const char* e) { cout << e << endl; }
    catch (int e) { cout << "HRESULT: " << e << endl; }

    return 0;
}

string intToString(int number)
{
	stringstream convert;
	convert << number;

	return convert.str();
}
wchar_t* getWC(const char* c)
{
	wchar_t* wc = new wchar_t[strlen(c) + 1];
	mbstowcs(wc, c, strlen(c) + 1);

	return wc;
}